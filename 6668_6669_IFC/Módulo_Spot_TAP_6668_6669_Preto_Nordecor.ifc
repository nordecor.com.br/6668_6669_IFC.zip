Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-14T23:21:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Dec 14 23:21:52 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\3581d617-6b7f-40f0-a361-ccd3f05f70d3\779151ae-8f66-4644-b106-14c2263c5676\ifc * Database version: 5507 * Database creation date: Sat Dec 14 23:21:51 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Dec 14 23:21:52 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Dec 14 23:21:52 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_329519
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6669 - Preto, Módulo_Spot_TAP_6668_6669_Nordecor_IFC:6669 - Preto:329519
In: Nível 1
Type - Material: Plástico - Acrílico - Transparente, Metal - Alumínio - Anodizado, Metal - Alumínio - Preto, LED
Type - Cotas - Altura da colocação: 0 mm; Altura da luminária: 62.5 mm; Comprimento: 44.3 mm; Largura: 44.3 mm
Type - Dados - Data da atualização: 13/12/2024; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Módulo de embutir tipo downlight, acabamento preto, LED 5W, 2700K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Clique; Garantia: 2 anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6669; Nome do tipo: 6669 - Preto; Número OmniClass: 23.80.70.11.14.11; Tipo de imagem: Imagem raster: 6669.png; Título OmniClass: Downlights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/modulo-downlight-led-tap-5w-2-700k-irc90-3/
Type - Elétrico - Comentários de voltagem: 85-265V; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Fator de potência - Luminária: 0.5; Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.095
Type - Fotométricos - Fluxo luminoso: 370 lm; Grau de abertura: 24 deg; IRC (RA): >90; Potência: 5 W; SDMC: <3; Temperatura de cor: 2700 K; UGR: <13
Type - Gráficos - Simbologia: Imagem raster: 6669 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Acrílico - Transparente; Luminária: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Módulo_Spot_TAP_6668_6669_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 1 Clique: no; 2D: yes; Anti ofuscamento: no; Fonte Luminosa: yes
Cotas - Área: 0.0152579 m2; Volume: 0.0000275968 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Módulo_Spot_TAP_6668_6669_Nordecor_IFC: 6669 - Preto; Família e tipo: Módulo_Spot_TAP_6668_6669_Nordecor_IFC: 6669 - Preto; ID de tipo: Módulo_Spot_TAP_6668_6669_Nordecor_IFC: 6669 - Preto; Tipo: Módulo_Spot_TAP_6668_6669_Nordecor_IFC: 6669 - Preto
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
